# Keil uVision project ValueControl.uvprojx, settings and files
target spi_master_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19x.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ValueControl +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fgnu89-inline
  c include: ..\source;..\mcu\common;..\mcu\driver\inc;..\source\extra\SEGGER_RTT_V760c\Config;..\source\extra\SEGGER_RTT_V760c\RTT;..\source\extra\simplegui\GUI\inc;..\source\extra\simplegui\HMI\inc;..\source\common;..\source\app\AutoAdjust;..\source\app\AutoControl;..\source\app\resource;..\source\app\System;..\source\app\control;..\source\driver\extra;..\source\driver\mcu;..\source\page\AutoAdjust;..\source\page\AutoControl;..\source\page\common;..\source\page\font;..\source\page\home;..\source\page\image;..\source\page\language;..\source\page\main;..\source\page\menu;..\midware\FreeRTOS\FreeRTOS\Source\include;..\midware\FreeRTOS\FreeRTOS\Source\portable\GCC\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group HC32_LIB
    ../mcu/driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group HC32_COF
    ../mcu/common/: interrupts_hc32l19x.c system_hc32l19x.c
    ../mcu/: startup_hc32l19x.s
  group main
    ../source/: main.c freertos_hooks.c
    ../source/common/: error.c DataPort.c common.c
  group app
    ../source/app/resource/: bmp.c
    ../source/app/System/: Save.c System.c AppManage.c SystemServer.c Flash_RW.c
    ../source/app/AutoControl/: ValveParam.c ValvePID.c ValveOutput.c ValveControl.c TestDrive.c
  group control
    ../source/app/control/: buffer.c
    ../source/app/math/: fitted_curve.c
  group debug
    ../source/extra/SEGGER_RTT_V760c/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SimpleguiGUI
    ../source/extra/simplegui/GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_Curve.c SGUI_FontResource.c SGUI_IconResource.c SGUI_Interface.c SGUI_ItemsBase.c SGUI_List.c SGUI_Menu.c SGUI_Notice.c SGUI_PolarCoordinates.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c SGUI_VariableBox.c
    ../source/extra/simplegui/HMI/src/: HMI_Engine.c
  group driver
    ../source/driver/mcu/: IIC.c LowPowerTimer.c SPI0.c UserADC.c UserDac.c UserTim4.c UserTim6.c UserUart1.c
    ../source/driver/extra/: Disp.c key.c led.c ADX111.c KTH5702.c
  group GUI_Page
    ../source/page/common/: GUICountDown.c SaveBox.c SetValueBox.c GUIPublic.c Draw.c
    ../source/page/home/: GUIHome.c
    ../source/page/main/: GUIMain.c
    ../source/page/menu/: GUICurve.c GUIDebugPage1.c GUIInputSet.c GUIMechanical.c GUIMenuAll.c GUIModule.c GUISystem.c GUITest.c GUITravel.c GUIAutoSet.c
    ../source/page/AutoControl/: GUIAuto2.c
    ../source/page/AutoAdjust/: AutoAdjust.c
    ../source/page/menu/calib/: GUICalib.c
    ../source/page/menu/ControlParameter/: GUI_ControlParameter.c GUI_IPParameter.c GUI_TravelParameter.c
  group GUI_Language
    ../source/page/language/: language.c language_en.c language_zh.c
    ../source/page/font/: FontBigNumber.c FontUft8.c segmentCodeScreen.c FontAscii_w8h16.c
  group GUI_Image
    ../source/page/image/: ImageAuto.c ImageControl.c ImageFeedback.c ImageInput.c ImageMechanicalState.c ImagePST.c ImageSystem.c ImageTravel.c ImageFinish.c image_temp.c image_input.c image_auto_set.c image_manual.c image_mode_auto.c image_485.c image_mode_move.c
  group README
    ../: Readme.md
  group FreeRtos
    ../midware/FreeRTOS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../midware/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../midware/FreeRTOS/FreeRTOS/Source/portable/GCC/ARM_CM0/: mpu_wrappers_v2_asm.c port.c portasm.c
software components: CMSIS:CORE 5.5.0
