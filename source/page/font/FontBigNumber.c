/*************************************************************************/
/** Copyright.                                                          **/
/** FileName: Resource.c                                                **/
/** Author: Polarix                                                     **/
/** Version: 1.0.0.0                                                    **/
/** Description: BigNumber font resource data, used FZXS-12 font.          **/
/*************************************************************************/
//=======================================================================//
//= Include files.                                                      =//
//=======================================================================//
#include "FontBigNumber.h"

//=======================================================================//
//= Static function declaration.                                        =//
//=======================================================================//
static SGUI_INT GetCharIndex_BigNumber(SGUI_UINT32 uiCode);
static SGUI_CSZSTR StepNext_BigNumber(SGUI_CSZSTR cszSrc, SGUI_UINT32 *puiCode);
static SGUI_SIZE BigNumber_GetFontData(SGUI_SIZE sStartAddr, SGUI_BYTE *pDataBuffer, SGUI_SIZE sReadSize);
static SGUI_BOOL BigNumber_IsFullWidth(SGUI_UINT32 uiCode);

//=======================================================================//
//= Global variable declaration.                                        =//
//=======================================================================//
/*" !\"#$%&,()*+,-./0123456789:;<=>?@ABCDEFGHIJKLMNOPQRSTUVWXYZ[/]^_'abcdefghijklmnopqrstuvwxyz{|}`"*/
const SGUI_BYTE BigNumber_H24[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*" ",0*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, /*"!",1*/
    0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x18, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x70, 0x80, 0x00, /*"\",2*/
    0x00, 0x00, 0x80, 0x60, 0x30, 0x1C, 0x8C, 0x60, 0x30, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*""",3*/
    0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x83, 0x83, 0xFF, 0x83, 0x83, 0x83, 0x83, 0xFB, 0x87, 0x83, 0x00,
    0x00, 0x01, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x01, 0x01, 0x00, /*"#",4*/
    0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0xF8, 0x20, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x07, 0x0C, 0x18, 0xFF, 0x71, 0xE1, 0x81, 0x00, 0x00,
    0x00, 0x00, 0x07, 0x0F, 0x12, 0x10, 0x7F, 0x10, 0x0F, 0x07, 0x00, 0x00, /*"$",5*/
    0xC0, 0x30, 0x10, 0x30, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x07, 0x18, 0x10, 0x18, 0xCF, 0x38, 0xC6, 0x31, 0x10, 0x30, 0xC0, 0x00,
    0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x18, 0x10, 0x18, 0x07, 0x00, /*"%",6*/
    0x00, 0x00, 0xE0, 0xF0, 0x10, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x17, 0x3F, 0xF8, 0xC7, 0x03, 0x08, 0xF8, 0x08, 0x08, 0x00,
    0x07, 0x0F, 0x18, 0x10, 0x10, 0x13, 0x0F, 0x0E, 0x19, 0x10, 0x10, 0x0C, /*"&",7*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x8C, 0x4C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*",",8*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x10, 0x20, 0x40, 0x00, /*"(",9*/
    0x00, 0x04, 0x08, 0x10, 0x60, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x40, 0x20, 0x10, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*")",10*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x24, 0x38, 0x10, 0xFF, 0x18, 0x3C, 0x24, 0x66, 0x66,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, /*"*",11*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, /*"+",12*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x8C, 0x4C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*",",13*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*"-",14*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*".",15*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x60, 0x38, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, /*"/",16*/
    0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
    0x00, 0x01, 0x07, 0x0E, 0x18, 0x10, 0x10, 0x18, 0x0E, 0x07, 0x01, 0x00, /*"0",17*/
    0x00, 0x00, 0x40, 0x40, 0x40, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x10, 0x10, 0x10, 0x1F, 0x1F, 0x10, 0x10, 0x10, 0x00, 0x00, /*"1",18*/
    0x00, 0x80, 0x40, 0x20, 0x20, 0x20, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x1F, 0x07, 0x00, 0x00,
    0x00, 0x18, 0x1C, 0x12, 0x11, 0x10, 0x10, 0x10, 0x10, 0x1E, 0x00, 0x00, /*"2",19*/
    0x00, 0xC0, 0xC0, 0x20, 0x20, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x00, 0x10, 0x10, 0x18, 0x2F, 0xE7, 0x80, 0x00, 0x00,
    0x00, 0x0E, 0x0E, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x07, 0x00, 0x00, /*"3",20*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xA0, 0x98, 0x84, 0x83, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x1F, 0x1F, 0x10, 0x10, 0x00, /*"4",21*/
    0x00, 0x00, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x10, 0x08, 0x08, 0x08, 0x18, 0xF0, 0xE0, 0x00, 0x00,
    0x00, 0x07, 0x0B, 0x10, 0x10, 0x10, 0x10, 0x1C, 0x0F, 0x03, 0x00, 0x00, /*"5",22*/
    0x00, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x20, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0x21, 0x10, 0x08, 0x08, 0x08, 0x18, 0xF0, 0xE0, 0x00,
    0x00, 0x01, 0x07, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x08, 0x0F, 0x03, 0x00, /*"6",23*/
    0x00, 0x00, 0xC0, 0x60, 0x20, 0x20, 0x20, 0x20, 0x20, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, /*"7",24*/
    0x00, 0x80, 0xC0, 0x60, 0x20, 0x20, 0x20, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x00, 0x83, 0xCF, 0x6C, 0x18, 0x10, 0x30, 0x30, 0x68, 0xCF, 0x83, 0x00,
    0x00, 0x07, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x07, 0x00, /*"8",25*/
    0x00, 0x00, 0xC0, 0xC0, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0x60, 0x40, 0x40, 0x40, 0x20, 0x10, 0xFF, 0xFE, 0x00,
    0x00, 0x00, 0x0C, 0x1C, 0x10, 0x10, 0x10, 0x08, 0x0F, 0x03, 0x00, 0x00, /*"9",26*/
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, /*":",27*/
};

const SGUI_FONT_RES BigNumber_FZXS24 =
    {
        /*SGUI_INT                      iHalfWidth*/ 12,
        /*SGUI_INT                      iFullWidth*/ 24,
        /*SGUI_INT                      iHeight*/ 24,
        /*SGUI_FN_IF_GET_CHAR_INDEX     fnGetIndex*/ GetCharIndex_BigNumber,
        /*SGUI_FN_IF_GET_DATA           fnGetData*/ BigNumber_GetFontData,
        /*SGUI_FN_IF_STEP_NEXT          fnStepNext*/ StepNext_BigNumber,
        /*SGUI_FN_IF_IS_FULL_WIDTH      fnIsFullWidth*/ BigNumber_IsFullWidth};

//=======================================================================//
//= Function define.                                                    =//
//=======================================================================//
/*************************************************************************/
/** Function Name:  GetCharIndex_BigNumber                                 **/
/** Purpose:        Get character index in font library.                **/
/** Resources:      None.                                               **/
/** Params:                                                             **/
/** @ uiCode[in]:   Character code.                                     **/
/** Return:         Character index.                                    **/
/*************************************************************************/
SGUI_INT GetCharIndex_BigNumber(SGUI_UINT32 uiCode)
{
    /*----------------------------------*/
    /* Variable Declaration             */
    /*----------------------------------*/
    SGUI_INT iIndex;
    SGUI_UINT8 uiLowByte, uiHighByte;

    /*----------------------------------*/
    /* Initialize                       */
    /*----------------------------------*/
    // Initialize variable.
    iIndex = SGUI_INVALID_INDEX;

    /*----------------------------------*/
    /* Process                          */
    /*----------------------------------*/
    /* for ASCII characters. */
    if ((uiCode > 0x19) && (uiCode < 0x7F))
    {
        iIndex = uiCode - (0x20) + 1;
    }
    else
    {
        iIndex = 0;
    }
    return iIndex;
}

/*************************************************************************/
/** Function Name:  StepNext_BigNumber                                     **/
/** Purpose:        Read current character code order by input pointer  **/
/**                 and step to next character start pointer.           **/
/** Resources:      None.                                               **/
/** Params:                                                             **/
/** @ cszSrc[in]:   Current char pointer.                               **/
/** @ puiCode[in]:  Character code.                                     **/
/** Return:         Next character start pointer.                       **/
/*************************************************************************/
SGUI_CSZSTR StepNext_BigNumber(SGUI_CSZSTR cszSrc, SGUI_UINT32 *puiCode)
{
    /*----------------------------------*/
    /* Variable Declaration             */
    /*----------------------------------*/
    const SGUI_CHAR *pcNextChar;
    SGUI_UINT32 uiCode;

    /*----------------------------------*/
    /* Initialize                       */
    /*----------------------------------*/
    pcNextChar = cszSrc;
    uiCode = 0;

    /*----------------------------------*/
    /* Process                          */
    /*----------------------------------*/
    if (NULL != pcNextChar)
    {
        do
        {
            uiCode = (SGUI_BYTE)(*pcNextChar++);
            if (uiCode < 0x7F)
            {
                break;
            }
            uiCode = uiCode << 8;
            uiCode |= (SGUI_BYTE)(*pcNextChar++);
        } while (0);
    }
    *puiCode = uiCode;

    return pcNextChar;
}

/*************************************************************************/
/** Function Name:  BigNumber_GetFontData                                  **/
/** Purpose:        Read character data form font data.                 **/
/** Resources:      None.                                               **/
/** Params:                                                             **/
/** @ sStartAddr[in]: Read start address in memory.                     **/
/** @ pDataBuffer[in]: Character data dump buffer pointer.              **/
/** @ sReadSize[in]: Size of data will be read, always mean the buffer  **/
/**                 size.                                               **/
/** Return:         Data in process was be read.                        **/
/*************************************************************************/
SGUI_SIZE BigNumber_GetFontData(SGUI_SIZE sStartAddr, SGUI_BYTE *pDataBuffer, SGUI_SIZE sReadSize)
{
    /*----------------------------------*/
    /* Variable Declaration             */
    /*----------------------------------*/
    SGUI_SIZE sReadCount;
    const SGUI_BYTE *pSrc = BigNumber_H24 + sStartAddr;
    SGUI_BYTE *pDest = pDataBuffer;

    /*----------------------------------*/
    /* Initialize                       */
    /*----------------------------------*/
    pSrc = BigNumber_H24 + sStartAddr;
    pDest = pDataBuffer;

    /*----------------------------------*/
    /* Process                          */
    /*----------------------------------*/
    if (NULL != pDataBuffer)
    {
        for (sReadCount = 0; sReadCount < sReadSize; sReadCount++)
        {
            *pDest++ = *pSrc++;
        }
    }
    return sReadCount;
}

/*************************************************************************/
/** Function Name:  BigNumber_GetFontData                                  **/
/** Purpose:        Read character data form font data.                 **/
/** Resources:      None.                                               **/
/** Params:                                                             **/
/** @ sStartAddr[in]: Read start address in memory.                     **/
/** @ pDataBuffer[in]: Character data dump buffer pointer.              **/
/** @ sReadSize[in]: Size of data will be read, always mean the buffer  **/
/**                 size.                                               **/
/** Return:         Data in process was be read.                        **/
/*************************************************************************/
SGUI_BOOL BigNumber_IsFullWidth(SGUI_UINT32 uiCode)
{
    /*----------------------------------*/
    /* Variable Declaration             */
    /*----------------------------------*/
    SGUI_BOOL bReturn;

    /*----------------------------------*/
    /* Process                          */
    /*----------------------------------*/
    if (uiCode < 0x7F)
    {
        bReturn = SGUI_FALSE;
    }
    else
    {
        bReturn = SGUI_TRUE;
    }

    return bReturn;
}
